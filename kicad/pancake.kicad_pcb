# Repository kasasiki3/hard-pancake

File readme.md:

# 固いパンケーキモータードライバ

5010クラスのBLDCをFOCで駆動し、ついでにRZ-735等のブラシ付きDCモーターも駆動する、CAN-FD接続の1ch 3相モータードライバ。
当面はブラシ付き（735）で使い、将来BLDC（5010）へ流用する。基板は同一、ファームの切り替えで対応する。

決定済みの部品は [BOM.md](BOM.md)。

## 仕様

| 項目 | 仕様 | 備考 |
|---|---|---|
| 対応モーター | 3相BLDC（FOC）／ブラシ付きDC | DCは3相のうち2相をHブリッジとして使う |
| 電源電圧 | 12V〜24V公称（3S〜6S LiPo） | 動作範囲 10V〜25.2V。入力TVS（SMBJ30A、クランプ48.4V）以降の部品は全て耐圧50V以上 |
| 電流 | ピーク30A／平均5A程度（ロボコン足回り想定） | 過電流はハードウェアで遮断 |
| 通信 | CAN-FD 1ch、絶縁（CA-IS2062A、最大5Mbps、絶縁電源内蔵） | コネクタはRJ45×2（デイジーチェーン）。ピン配置は桔梗の雛形に合わせる（1-2 CAN1 H/L、3-6 CAN2 H/L、4-5 12V、7-8 GND）。CAN1につなぐ。CAN2へは表面実装のはんだジャンパ（JP3・JP4、既定はCAN1側が銅箔で接続）で変更できる。CAN側はGND_ISOの島にして基板のGNDと分ける（RJ45の7-8番、ESD保護、終端のコンデンサもGND_ISO）。12Vは2つのRJ45の間を島の中で素通しするだけで基板では使わない。終端はスプリット終端をはんだジャンパで切替 |
| マイコン | STM32G474CBT6（LQFP-48、Flash 128KB） | Cortex-M4F 170MHz、FDCAN、OPAMP、COMP、DAC。回路図のシンボルはピン互換のSTM32G431CBTxのまま。HSEは8MHz水晶（CANのクロック精度のため） |
| 電流検出 | 3相ローサイドシャント0.5mΩ＋DRV8323RH内蔵アンプ（40倍） | 出力は1.65V−20mV/A（±約70A）。0点はCAL（PB1）で較正する |
| 過電流保護 | (1) DRV8323RHのVDS監視（0.13V、4µsで全OFF、4ms後に再試行）。マイコンのプログラムに依存しない (2) アンプ出力→内蔵COMP＋内蔵DAC→TIM1ブレーク | (1)は常温で約65A、高温で約36Aが目安。nFAULTはTIM1_BKIN（PB12）にも入れる |
| 電圧検出 | VBUS分圧（100k/5.6k、約62Vフルスケール、1nF）をADCとCOMP3（PA0）へ | 過電圧（28V目安）で回生電流を絞り、それでも上がれば全OFF（惰性） |
| 温度検出 | FET近傍のNTC（10kΩ）をADCへ | |
| エンコーダ | 2ポート（JST XA 6ピン）。ポート1: ABZ または SSI（既定3.3V、JP5で5V切替可・5V時はABZ専用）、ポート2: ABZ（既定5V、JP6で3.3V切替可） | MT6701（3.3V）とAMT102/103等の5Vエンコーダに対応。信号線は直列抵抗100Ω＋ESD保護（VBUS=+5V）。端子のVCCの横に1µF（C49・C50）。ポート2は5Vトレラントのシュミットトリガバッファ（SN74LVC1G17DBVT×3、3.3V駆動）を通してPA6/PA4/PA5へ入れる。MT6701のABZ/SSI出力はプッシュプル（データシート1.8版 p.8）なのでプルアップ抵抗は付けない |
| 電源系統 | VBUS → DRV8323RH（ゲート駆動電源、5V 0.6A降圧を内蔵）→ 3.3V（RT9013、MCU・エンコーダ） | 3.3V LDOの入力は5VとSWDコネクタの5V（ST-Link V2互換品の5V出力）をダイオードOR（BAT54C）。ST-Linkだけでも MCU・エンコーダが動く（ゲート駆動とCANは動かない） |
| デバッグ | SWD（ST-Link V2互換品）＋CAN | SWDコネクタはJST PH 5ピン（B5B-PH-K-S）、1: 5V、2: SWDIO、3: SWCLK、4: NRST、5: GND。ST-Link側の2×5ヘッダとは変換ケーブルを1本作ってつなぐ。BOOT0は10kでGNDに固定。リセットボタン（TS-1187A-B-A-B、NRST–GND）あり。UART（PA2/PA3）は未使用 |
| 製造 | PCBA（JLCPCB想定） | 供給安定と単価を部品選定の第一条件にする |

## エンコーダ端子の信号

- 両ポートとも JST XA 6ピン（縦置き）：1: VCC、2: GND、3: GND、4: A、5: B、6: Z
- 電源はポートごとに3ピンはんだジャンパで切替（JP5: ポート1 既定3.3V/5V、JP6: ポート2 既定5V/3.3V）。
- MT6701はABZとSSIが同じピンを共用する（A=DO、B=CLK、Z=CSN）。どちらを出すかはセンサ側のMODEピンで選ぶので、同時には使えない。
- ABZはタイマのエンコーダモードに入れる（ポート1: TIM4 PB6/PB7＋Z PB5、ポート2: TIM3 PA6/PA4＋Z PA5）。
- ポート1のA/BはSPI3（PB4 MISO、PB3 SCK）にも配線してあり、SSIのときはSPIを受信専用で使う。CSNはPB5をGPIO出力にして駆動する。

## 設計方針

- 3相ハーフブリッジ×3を常に実装し、ブラシ付きDCは2相（例: U-V）でHブリッジ駆動する。残り1相は未使用。
- プログラムを間違えても壊れないことを優先する。貫通・短絡・ロックの保護はDRV8323RHの抵抗設定で行い、マイコンに頼らない。
- 電流検出はDRV8323RH内蔵アンプを使う。
- 部品はJLCの在庫が多く単価の安いものを選ぶ。

## ファームの前提

- 駆動電流はIDRIVE 18kΩで30/60mA、VDS監視は18kΩで0.13V、ゲインはDVDD直結で40倍、PWMは6x。試作で波形を測り、IDRIVEを75kΩ（60/120mA）やVDSを75kΩ（0.26V）へ変更できる。ただしIDRIVEを上げるのは試作でSPxの負側を測ってから（C45〜C47が無いと−8.6Vになる計算）。スナバのパッドは削除した（2026-11-26）。
- デッドタイムはDRV8323RHがゲート電圧を見て自動で入れる（＋100ns）。ファームでもTIM1に500ns（DTG=85）を入れる。
- ENABLEはPB2（リセット中は内部プルダウンで停止）、CALはPB1、nFAULTはPB12。
- 電流はPA1（COMP1）、PA7（COMP2）、PB0（COMP4）で3相とも過電流を見る。しきい値はDAC3を使う（DAC1の外部出力はエンコーダ2のPA4/PA5と重なる）。正の電流でアンプ出力は下がる。
- 起動直後にUCPDのデッドバッテリーを無効にする（UCPD1_DBDIS=1）。SWOは使わない（PB3がエンコーダ1のB）。
- VBUSの過電圧はCOMP3（PA0）→TIM1ブレークで止める（しきい値30V目安=1.59V）。基準はDAC1の内部接続を使う想定（PA4をエンコーダ2に使いながらできるかはRM0440で未確認）。できなければADCのアナログウォッチドッグで止める。
- ENABLEを下げる前にINHx/INLxを全てLにする（PWM中に下げるとゲートがHi-Zのまま残る。データシート8.4.1.1）。
- VDS保護は4msごとに再試行し続けるので、nFAULTでTIM1を止めたままにする（AOE=0）。ゲート故障（GDF）の解除はENABLEを8〜40µs下げる。
- CANが途切れたら止める。低電圧（LiPo保護）で止める。電流は連続約6A（入力コンデンサのリップル定格: 1.4A×20kHz帯の係数0.70×3個=2.94Arms、データシートp.8）・ピーク30Aの時間をI²tで制限する。
- 電流のサンプルは低側が3µs以上開くデューティに制限する（40倍の整定が1.2µs）。
- COMPは片側（正の電流）しか見ないので、1相が−2I・2相が+Iの角度では各相のCOMPに半分しか出ない。ADCのアナログウォッチドッグで上下とも見る。
- CSAのオフセットは±4mV（±8A相当）、ドリフトは10µV/℃（20mA/℃）。CAL（PB1）での較正を起動時だけでなく停止中・ゼロベクトル中にもやり直す。
- NTC_SENSE（PB11）にはコンデンサが無く源インピーダンスは5kΩなので、ADCのサンプル時間を長く（92.5サイクル以上）取る。
- 高側ON中の相–GND短絡はシャントを通らず、VDS監視（4µs）だけが守る（LTspiceの近似で176〜685A、`review/findings_opus.md`）。
- ウォッチドッグはオプションバイトでハード起動にし、デバッグ停止中はTIM1の出力を止める。

## 決定の経緯

- エンコーダ端子2つを右辺へ移し、基板を81×68mmから92×68mmに広げた（2026-11-26）。前は右下のねじ穴と電解の間で、背の高い電解とモーター線に囲まれて挿しにくかったため。縦型のまま、1番ピンを上・ロックの突起を外側にして上にENC2、下にENC1を並べた。取付穴も右へずらし82×59mm間隔（moteusとの互換は無くなった）。端子のVCCの横に1µFを足した（ケーブルから入るノイズ・ESD対策。3.3V・5Vは内層ベタで来るので、LDOから離れていることは問題にならない）。信号名のシルクはパッドの位置から書くようにし、基板全体の文字の重なり（DRCのシルク警告）も直した。配線は、Freeroutingで全部引き直すと電源段の束（ゲート・SH・検出線）を使わず検出線のSP/SNが離れ、周りを固定するとエンコーダの線が引けなかったので、前回の配線（`tools/routes_81.json`）を固定で残し、エンコーダ端子の8本だけ `tools/route_enc.py` で引いた（手順は `tools/fr_route.py` の先頭）。DRCはエラー0。
- マイコンをSTM32G431CBT6からSTM32G474CBT6（C730123）に変更した（2026-11-26）。G431CBT6がJLCで在庫切れのため。同じLQFP-48で全ピン互換（ST公式ピンデータ、`review/まとめ.md`）、Flashは同じ128KB。64KBのG431C8T6は、FOC＋FDCANの参考ファーム（FOC2）をビルドすると-O2で41KB、-O0で65KBになり余裕がないので採らなかった。UFQFPN-48のCBU6はピン番号が25本ずれ、基板の作り直しになるので採らなかった。
- 基板の見直しを4周した（2026-11-26、LTspice `sim/`、Gemini 4 Neonの査読）。81×68mm。直したもの: ゲート線の余分なループ、シャントのSP銅、降圧の入力ループ、TVSの位置、水晶横のVBUS線、ESDの並び、検出線とゲート線の間隔（0.5mm以内の並走は各2mm以下）。LTspiceの近似ではC45〜C47を実装すると、ループの寄生が想定の2倍でもSPxが±3V（200ns）に収まる。縮小案のうち、相の間隔15mm・高さ66mmは、上半分の幅とVBUSの抵抗のため採らない。
- 回路・基板を査読した（2026-11-26、Gemini 4 Carbon High×2・Opus 5.5 max、[review/まとめ.md](review/まとめ.md)）。作ると動かない・壊れる誤りは無し。直したもの: 主要部品のLCSC番号（純正品を指定。互換品(ES)が入らないように）、DRVのサーマルビアの裏面をソルダマスクで塞ぐ、D1を単方向の記号に、モーターパッドをBOMから除外、C12/C13のGNDをベタ接続、シミュの低側ドライバをPGND基準に修正（データシート表6-4）。修正後のシミュ（`sim/run_review.py`）ではC45〜C47が無いとSPxの負側が−3.3V（寄生2倍で−6.3V、絶対最大は200nsで−3V）、付けると−0.6V（−0.9V）。裏面に部品を置かない方針なので、C45〜C47は表面の高側FETの左（VBUSバーの上）へ移し、SPは裏面のSPベタを上へ広げて2本のビアでつないだ（FETの右は裏面がゲート・検出線の束でビアを打てない）。真下より配線の誘導分が増え、シミュ（`sim/run_c45L.py`）では3nHで−1.6V（寄生2倍で−2.0V）、5nHで−2.1V（−2.9V）。部品はJLCの基本部品の1µF 50V X7R 1206（C1848）。容量はほぼ効かず、25V時の実効0.3µFでも−1.3V（`sim/run_c45C.py`）。試作でSPxを測る。スナバ（裏面の未実装パッド）は削除した（シミュでVDSの跳ね31.6V対31.3V）。製造データは `python tools/export_jlc.py` で `kicad/production/` に出す（発注時の注意は `kicad/production/発注メモ.md`）。
- 基板を作った（2026-11-25、`kicad/pancake.kicad_pcb`）。81×68mm（角R4.5）、4層、1oz。部品は全て表面（裏面には部品を置かない）。左辺にRJ45×2とXT60、下辺にモーター出力3つとエンコーダ2つ（右端、右下ねじ穴の奥に縦に並べる）。XT60の＋がそのままVBUSバーの端で、電解3個は各相のFETの隣に1個ずつ置く。VBUSバーはL1・L3・L4、L2はGND、相の帯と下端のGND帯は4層。XT60からの往復抵抗の計算値（`tools/check_pcb.py`、1oz）: A 1.2、B 1.9、C 2.5mΩ、電解→FETは0.15〜0.28mΩ。波形は `sim/run_phases.py`（LTspice、近似モデル）。ブラシ付きはB–Cで使う（Bはゲート線が最短、温度センサはCの横）。島との銅箔の間隔は3.2mm以上。作り方は `tools/gen_pcb.py`。仮に決めたもの: エンコーダはJST XH 5ピン（B5B-XH-A、SWDのPHと挿し間違えない）、モーターのパッドと取付穴はmoteus r5（Apache-2.0）の形。パッドは6mm角へ1.47倍（中央2.8mm穴、四隅1.3mm穴、ビア20個）、取付穴はM3（3.2mm穴、5.45mmパッド、ビア8個、どこにもつながない）を角のRと同心で四隅に置く（72×59mm間隔、左上はCANの島の銅を避けてある）。ENC1はABZ/SSI、ENC2はABZで、信号名をシルクに書いた。KiCad標準のXT60は1番が−で回路図と逆なので、番号を入れ替えたフットプリントを使う。
- 設計チェック（2026-11-25、[設計チェック.md](設計チェック.md)）の指摘を反映した。仕様のピークを40Aから30Aにした（VDS監視0.13Vは高温で約35Aで働き、40Aを保証できないため）。シャントの検出線（SPx、SNx）とVDRAINにネットタイ、各相にVBUS〜低側ソースの未実装パッド（1µF 100V 1206）、テストポイント20個を追加。VBUS_SENSEを10nFから1nFにした。FETはonsemi純正を指定する（互換品のNTMFS5C628NLT1G(ES)はゲート電荷102nCでtDRIVE 4µsに余裕がない）。電源の逆接続はXT60の極性で防ぎ、基板に対策は入れない。

- JLCのフィーダ費と在庫のため、受動部品をBasic／Preferredに寄せた（2026-11-25）。1µF・4.7µF・10µF・22µFはX5R（DRV8323RHの指定はX5RかX7R）、チャージポンプの47nFは50V品、100nF 100Vは0805。CAN終端の60.4Ωは120Ω×2並列、5V降圧の分圧は100k/18k（5.02V）。リセットボタンは在庫5個のTL3342からTS-1187A-B-A-Bに変更。相の2.2µF 100VだけはBasicに100V品が無いのでExtendedのまま。
- 減速の回生は電池に戻すのを基本とし、電流を30A程度に制限する（2026-11-25）。短絡ブレーキは使わない。735は約0.115Ωなので、全速で短絡すると約217Aになるため。
- 入力の電解コンデンサを220µF 50V×2からハイブリッドの100µF 63V×3（118EC447、1個1.4A、30mΩ）に変更した（2026-11-25）。前のものはリップルが1個220mAで足りず、50VはTVSのクランプ48.4Vに余裕がないため。
- 電源側に30Aのブレードヒューズを外付けする（2026-11-25）。基板には載せない。役目は配線・電池の焼損とロックしっぱなしを止めること。FETの短絡はVDS監視、通常の電流はCOMPの30〜35A制限（ファーム）で守る。RZ-735VA 9517はメーカー値で停動156A（18V、約0.115Ω）なので、ファームの電流制限は必須。
- ゲートドライバをDRV8300DRGERからDRV8323RHに変更した（2026-11-25）。プログラムを間違えても壊れないように、貫通防止（VGS監視）と短絡・過電流の保護（VDS監視）をマイコンなしで働かせるため。12V電源（TPS7A4101）、5V降圧（LMR51625）、ゲート抵抗、ブートストラップは不要になった。
- CAN1/CAN2の切替をスライドスイッチからはんだジャンパに変更した（2026-11-25）。普段はCAN1だけ使うため。
- 回路レビュー（2026-11-25）を受けて修正した。終端ジャンパをCANH・CANLの両方に入れた。LED2をPC14からPB9へ、エンコーダ1 ZをPC13からPB5へ移した（PC13〜15は出力の制限がある）。
- CANトランシーバを非絶縁のTCAN1044Vから絶縁のCA-IS2062Aに変更した（2026-11-25）。電源のマイナス線だけが外れたとき、モーターの戻り電流がCANケーブルのGNDに流れるのを防ぐため。信号は容量結合（OOK変調）、島側の5Vは内蔵の絶縁DC-DCで作る。VISOOUTとVISOINは直結する（開放禁止）。
- 回路図はシート内を配線でつなぎ、ネットラベルを使わない形に作り直した（2026-11-23）。シートは電源・制御（MCU・CAN・エンコーダ）・パワー段の3枚で、シート間の信号は階層ラベルとルートシートの配線でつなぐ。配線が交差しにくいように、GPIOの割り当てを変更した（エンコーダ2 Z→PA5、LED1→PB10、LED2→PC14）。TCAN1044VのSTBはGNDに固定した（常時ノーマルモード）。
- USB Type-C・CH340C・自動書き込み回路を削除した（2026-11-24）。デバッグはSWDとCANで行い、机でMCUだけ動かすときはST-Link V2互換品の5Vで給電する。純正のST-Link（V2/V3MINIE）は基板へ給電できない（T_VCCは電圧検出の入力）ので、互換品を使う前提。SWDは小さく逆挿しできないJST PHにした（2.54mm 2×5ボックスヘッダは20×9mmで大きすぎる）。
- USB Type-Cを追加した（2026-11-23、翌日削除）。目的はデバッグ・書き込み・給電。MCU内蔵USBはFDCANとピン（PA11/PA12）が重なるため使わず、CH340CでUSART2につなぐ。
- エンコーダのシリアルはSPI（9ピン）をやめ、MT6701のSSIをABZと同じ3本で受ける形にした（2026-11-23）。I2Cはオープンドレインでケーブルのノイズに弱いため使わない。
- MCUはUFQFPN-32（KBU6）から LQFP-48（CBT6）に変更（2026-11-23）。エンコーダ2ポート＋SPIを追加するとPWM・OPAMP・FDCAN・SWDと合わせてGPIOが足りないため。CBT6の方が単価も安く在庫も多い（$3.09／4,672個 vs $7.23／350個）。
- 電源入力はXT60、モーター出力は基板に直接はんだ付けする（2026-11-24）。
- FETは60V品（NTMFS5C628NL、ODrive v3.4 48V版で採用実績）に仮決定（2026-11-22）。
- ゲートドライバはDRV8300DRGER、ゲート駆動電源はTPS7A4101で12V（2026-11-22）。DRV8300のGVDDは最大20Vで6Sを直接入れられないため。

## 未決事項

- CANのメッセージ定義

## 未確認リスト（2026-11-25）

- [ ] SWDだけで給電したとき、電源の入っていないDRV8323RH（VREF、nFAULT等）やCA-IS2062A（VDDP=0V）へ回り込まないか
- [ ] STM32G474のエラッタ（ES0430）を見直す（G474に変更、2026-11-26）。以下はG431時の記録: データシートは `datasheet/STM32G431CBT6.pdf` がDS12589 Rev 2（G431）の原本で、COMPのずれ（−9〜+3mV）とPC13〜15の制限は原本でも同じ値（2026-11-26確認）
- [ ] RT9013-33GB・ESDCAN24-2BLYの純正データシート（LCSCのPDFは別メーカー品だった）
- [ ] 8MHz水晶の負荷容量と15pFの適合（品のCLが12pFなら浮遊分込みで17.5pFになり、10pFへ下げると合う）
- [ ] フットプリント: RJ45（LCSC C385834の図面から自作。穴径0.9mmと前面までの距離は図面で読めず）、XT60PW-M（1番=＋）を実物と照合する。CA-IS2062Aは自作なのでJLCの部品データと照合する
- [ ] 端子: エンコーダ、電源入力、モーター出力
- [ ] 手元の735の型番・抵抗・インダクタンス（9517のメーカー値0.115Ωで設計している）
- [ ] 入力コンデンサ〜FET〜シャントのループのインダクタンス（目標8nH以下、15nHまでは計算上60V以内）
- [ ] 試作での波形: VDSの跳ね、SHxの傾き、ゲート、デッドタイム、SPxの負側（絶対最大は200nsで−3V）
- [ ] 試作での温度: FET、DRV8323RH、RT9013、BAT54C
- [ ] 5Vの消費（上限0.6A）と、3.3V系の消費（BAT54Cは200mA定格）
- [ ] 回生時のVBUSの上昇と、電池が受けられない場合の動作
- [ ] モーター線の短絡（計算ではFETの耐圧・パルス電流の規格を超える）
- [ ] DRV8323Rは純正SPICEモデルがなく、近似で計算した
- [ ] ヒューズの溶断特性（30A）

## KiCad design kicad/pancake.kicad_pcb

Parts:
C1, C2, C3: 100uF 63V; CP_Elec_10x10.5; MPN 118EC447; LCSC C46528099
C4, C5: 1uF 50V; C_0603_1608Metric; LCSC C15849
C6: 1nF; C_0402_1005Metric; LCSC C1523
D1: SMBJ30A; D_SMB; LCSC C113998
D2: BAT54C; SOT-23; LCSC C37704
J1: XT60PW-M; XT60PW-M_1plus_2minus; LCSC C98732
R1: 100k; R_0402_1005Metric; LCSC C25741
R2: 5.6k; R_0402_1005Metric; LCSC C25908
TP16: VBUS; TestPoint_Pad_D1.0mm
TP17: +5V; TestPoint_Pad_D1.0mm
TP18: +3V3; TestPoint_Pad_D1.0mm
TP19, TP20: GND; TestPoint_Pad_D1.0mm
U1: RT9013-33GB; SOT-23-5; LCSC C47773

Connections:
+3V3: C5.1, TP18.1, U1.5 (VOUT); also elsewhere on the board
+5V: D2.1, TP17.1; also elsewhere on the board
/制御 (MCU・CAN・エンコーダ)/SWD_5V: D2.2; also elsewhere on the board
/制御 (MCU・CAN・エンコーダ)/VBUS_SENSE: C6.1, R1.2, R2.1; also elsewhere on the board
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, D1.2 (A), J1.2, R2.2, TP19.1, TP20.1, U1.2 (GND); also elsewhere on the board
unnamed: C4.1, D2.3, U1.1 (VIN), U1.3 (EN)
VBUS: C1.1, C2.1, C3.1, D1.1 (K), J1.1, R1.1, TP16.1; also elsewhere on the board

Notes on the sheet:
電源入力・保護
3.3V LDO (RT9013)
VBUS電圧検出 (約62Vフルスケール)
テストポイント (電源)

Parts:
C28, C29, C30, C32, C34, C37, C39, C42, C48: 100nF; C_0402_1005Metric; LCSC C307331
C31: 4.7uF 16V; C_0603_1608Metric; LCSC C19666
C33, C40, C43, C49, C50: 1uF 50V; C_0603_1608Metric; LCSC C15849
C35, C36: 15pF; C_0402_1005Metric; LCSC C1548
C38, C41: 10uF 25V; C_0805_2012Metric; LCSC C15850
C44: 4.7nF; C_0402_1005Metric; LCSC C1538
D4, D5: LED; LED_0603_1608Metric; LCSC C2286
D6: ESDCAN24-2BLY; SOT-23; LCSC C246766
J5: エンコーダ1; JST_XA_B06B-XASK-1_1x06_P2.50mm_Vertical; LCSC C225449
J6: エンコーダ2; JST_XA_B06B-XASK-1_1x06_P2.50mm_Vertical; LCSC C225449
J7: SWD; JST_PH_B5B-PH-K_1x05_P2.00mm_Vertical; MPN B5B-PH-K-S; LCSC C157993
J8, J9: RJ45; RJ45_R-RJ45R08P-A004; MPN R-RJ45R08P-A004; LCSC C385834
JP1, JP2: 終端ON; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
JP3, JP4: CAN1/CAN2; SolderJumper-3_P1.3mm_Bridged12_RoundedPad1.0x1.5mm
JP5: ENC1 3V/5V; SolderJumper-3_P1.3mm_Bridged12_RoundedPad1.0x1.5mm
JP6: ENC2 5V/3V; SolderJumper-3_P1.3mm_Bridged12_RoundedPad1.0x1.5mm
R18: 10k; R_0402_1005Metric; LCSC C25744
R19, R20: 1k; R_0402_1005Metric; LCSC C11702
R21, R22, R23, R24, R25, R26: 100; R_0402_1005Metric; LCSC C25076
R27, R28, R29, R30: 120; R_0402_1005Metric; LCSC C25079
SW1: RESET; SW_Push_1P1T_XKB_TS-1187A; MPN TS-1187A-B-A-B; LCSC C318884
U3: STM32G474CBT6; LQFP-48_7x7mm_P0.5mm; LCSC C730123
U4, U5: SRV05-4; SOT-23-6; MPN SRV05-4-P-T7; LCSC C85364
U6: CA-IS2062A; CA-IS2062A_LGA-16_4.65x5.2mm_P0.65mm; LCSC C22438481
U7, U8, U9: SN74LVC1G17; SOT-23-5; MPN SN74LVC1G17DBVT; LCSC C2862344
Y1: 8MHz; Crystal_SMD_3225-4Pin_3.2x2.5mm; MPN TX32258M4FBDD2T; LCSC C5308003

Connections:
+3V3: C28.1, C29.1, C30.1, C31.1, C32.1, C33.1, C34.1, C40.1, C48.1, JP5.1 (A), JP6.3 (B), U3.1 (VBAT), U3.20 (VREF+), U3.21 (VDDA), U3.24 (VDD), U3.36 (VDD), U3.48 (VDD), U6.7 (VDDL), U7.5 (VCC), U8.5 (VCC), U9.5 (VCC); also elsewhere on the board
+5V: C38.1, C39.1, JP5.3 (B), JP6.1 (A), U4.5 (VBUS), U5.5 (VBUS), U6.6 (VDDP); also elsewhere on the board
/パワー段/DRV_CAL: U3.17 (PB1); also elsewhere on the board
/パワー段/DRV_EN: U3.18 (PB2); also elsewhere on the board
/パワー段/DRV_NFAULT: U3.26 (PB12); also elsewhere on the board
/パワー段/ISENSE_A: U3.9 (PA1); also elsewhere on the board
/パワー段/ISENSE_B: U3.15 (PA7); also elsewhere on the board
/パワー段/ISENSE_C: U3.16 (PB0); also elsewhere on the board
/パワー段/NTC_SENSE: U3.25 (PB11); also elsewhere on the board
/パワー段/PWM_AH: U3.30 (PA8); also elsewhere on the board
/パワー段/PWM_AL: U3.27 (PB13); also elsewhere on the board
/パワー段/PWM_BH: U3.31 (PA9); also elsewhere on the board
/パワー段/PWM_BL: U3.28 (PB14); also elsewhere on the board
/パワー段/PWM_CH: U3.32 (PA10); also elsewhere on the board
/パワー段/PWM_CL: U3.29 (PB15); also elsewhere on the board
/制御 (MCU・CAN・エンコーダ)/SWD_5V: J7.1; also elsewhere on the board
/制御 (MCU・CAN・エンコーダ)/VBUS_SENSE: U3.8 (PA0); also elsewhere on the board
GND: C28.2, C29.2, C30.2, C31.2, C32.2, C33.2, C34.2, C35.2, C36.2, C37.2, C38.2, C39.2, C40.2, C48.2, C49.2, C50.2, D4.1 (K), D5.1 (K), J5.2, J5.3, J6.2, J6.3, J7.5, R18.1, SW1.2, U3.19 (VSSA), U3.23 (VSS), U3.35 (VSS), U3.47 (VSS), U4.2 (GND), U5.2 (GND), U6.5 (GNDP1), U6.8 (GND1), U7.3 (GND), U8.3 (GND), U9.3 (GND), Y1.2 (G), Y1.4 (G); also elsewhere on the board
GND_ISO: C41.2, C42.2, C43.2, C44.2, D6.3 (A), J8.7, J8.8, J9.7, J9.8, U6.9 (GND2), U6.12 (GNDP2)
unnamed: C44.1, R27.2, R28.1, R29.2, R30.1
unnamed: D4.2 (A), R19.2
unnamed: D5.2 (A), R20.2
unnamed: C49.1, J5.1, JP5.2 (C)
unnamed: J5.4, R23.2, U4.1 (I/O1)
unnamed: J5.5, R22.2, U4.3 (I/O2)
unnamed: J5.6, R21.2, U4.4 (I/O3)
unnamed: C50.1, J6.1, JP6.2 (C)
unnamed: J6.4, R26.2, U5.4 (I/O3)
unnamed: J6.5, R24.2, U5.1 (I/O1)
unnamed: J6.6, R25.2, U5.3 (I/O2)
unnamed: J7.2, U3.37 (PA13)
unnamed: J7.3, U3.38 (PA14)
unnamed: C37.1, J7.4, SW1.1, U3.7 (PG10)
unnamed: J8.4, J8.5, J9.4, J9.5
unnamed: D6.1 (K), JP1.1 (A), JP3.2 (C), U6.15 (CANH)
unnamed: JP1.2 (B), R27.1, R29.1
unnamed: JP2.1 (A), R28.2, R30.2
unnamed: D6.2 (K), JP2.2 (B), JP4.2 (C), U6.14 (CANL)
unnamed: J8.1, J9.1, JP3.1 (A)
unnamed: J8.3, J9.3, JP3.3 (B)
unnamed: J8.2, J9.2, JP4.1 (A)
unnamed: J8.6, J9.6, JP4.3 (B)
unnamed: R24.1, U7.2
unnamed: R25.1, U8.2
unnamed: R26.1, U9.2
unnamed: U3.12 (PA4), U7.4
unnamed: U3.13 (PA5), U8.4
unnamed: U3.14 (PA6), U9.4
unnamed: U3.33 (PA11), U6.1 (RXD)
unnamed: U3.34 (PA12), U6.4 (TXD)
unnamed: R22.1, U3.40 (PB3), U3.44 (PB7)
unnamed: R23.1, U3.41 (PB4), U3.43 (PB6)
unnamed: R21.1, U3.42 (PB5)
unnamed: R18.2, U3.45 (PB8)
unnamed: R19.1, U3.46 (PB9)
unnamed: R20.1, U3.22 (PB10)
unnamed: C35.1, U3.5 (PF0), Y1.1
unnamed: C36.1, U3.6 (PF1), Y1.3
unnamed: C41.1, C42.1, C43.1, U6.10 (VISOIN), U6.11 (VISOOUT)

Notes on the sheet:
MCU
パスコン (VDD×3, VDDA, VREF+)
クロック
LED
エンコーダ1 (ABZ または SSI: A=DO, B=CLK, Z=CSN)
エンコーダ2 (ABZ、5V入力はSN74LVC1G17で3.3Vへ変換)
SWD (ST-Link V2互換品、5Vで給電も受ける)
絶縁CANトランシーバ (右側はGND_ISOの島)
CAN保護・スプリット終端・RJ45×2 (数珠つなぎ)

Parts:
C7, C8, C9: 1nF; C_0402_1005Metric; LCSC C1523
C10, C15: 1uF 50V; C_0603_1608Metric; LCSC C15849
C11: 100nF; C_0402_1005Metric; LCSC C307331
C12, C19, C22, C25: 100nF 100V; C_0805_2012Metric; LCSC C28233
C13: 10uF 50V; C_1206_3216Metric; LCSC C13585
C14, C20, C23, C26: 2.2uF 100V; C_1210_3225Metric; LCSC C55151
C16: 47nF 50V; C_0603_1608Metric; LCSC C1622
C17: 100nF 50V; C_0402_1005Metric; LCSC C307331
C18: 22uF 25V; C_1206_3216Metric; LCSC C12891
C45, C46, C47: 1uF 50V; C_1206_3216Metric; LCSC C1848
D3: SS16; D_SMA; LCSC C2481
J2: モーターA; MotorPad_6x6_moteus
J3: モーターB; MotorPad_6x6_moteus
J4: モーターC; MotorPad_6x6_moteus
L1: 22uH; L_Sunlord_SWPA6045S; MPN SWPA6045S220MT; LCSC C83454
NT1, NT2, NT3, NT4, NT5, NT6, NT7: NetTie; NetTie-2_SMD_Pad0.5mm
Q1, Q2, Q3, Q4, Q5, Q6: NTMFS5C628NLT1G; ONSemi_SO-8FL_488AA; LCSC C145537
R3, R17: 10k; R_0402_1005Metric; LCSC C25744
R4, R5, R6: 100; R_0402_1005Metric; LCSC C25076
R7, R8, R10: 18k; R_0402_1005Metric; LCSC C25762
R9: 100k; R_0402_1005Metric; LCSC C25741
R11, R13, R15: 0.5m; R_2512_6332Metric; MPN RLM25FEGMR50M; LCSC C710260
TH1: 10k NTC; R_0603_1608Metric; MPN NCP18XH103F03RB; LCSC C13564
TP1: GHA; TestPoint_Pad_D1.0mm
TP2: GLA; TestPoint_Pad_D1.0mm
TP3: SHA; TestPoint_Pad_D1.0mm
TP4: GHB; TestPoint_Pad_D1.0mm
TP5: GLB; TestPoint_Pad_D1.0mm
TP6: SHB; TestPoint_Pad_D1.0mm
TP7: GHC; TestPoint_Pad_D1.0mm
TP8: GLC; TestPoint_Pad_D1.0mm
TP9: SHC; TestPoint_Pad_D1.0mm
TP10: SOA; TestPoint_Pad_D1.0mm
TP11: SOB; TestPoint_Pad_D1.0mm
TP12: SOC; TestPoint_Pad_D1.0mm
TP13: VCP; TestPoint_Pad_D1.0mm
TP14: DVDD; TestPoint_Pad_D1.0mm
TP15: nFAULT; TestPoint_Pad_D1.0mm
U2: DRV8323RHRGZR; Texas_RGZ0048A_VQFN-48-1EP_7x7mm_P0.5mm_EP5.15x5.15mm_Therm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; LCSC C543035

Connections:
+3V3: C11.1, R3.1, R17.1, U2.26 (VREF); also elsewhere on the board
+5V: C18.1, L1.2, R9.1; also elsewhere on the board
/パワー段/DRV_CAL: U2.34 (CAL); also elsewhere on the board
/パワー段/DRV_EN: U2.33 (ENABLE); also elsewhere on the board
/パワー段/DRV_NFAULT: R3.2, TP15.1, U2.28 (nFAULT); also elsewhere on the board
/パワー段/ISENSE_A: C7.1, R4.2; also elsewhere on the board
/パワー段/ISENSE_B: C8.1, R5.2; also elsewhere on the board
/パワー段/ISENSE_C: C9.1, R6.2; also elsewhere on the board
/パワー段/NTC_SENSE: R17.2, TH1.1; also elsewhere on the board
/パワー段/PWM_AH: U2.37 (INHA); also elsewhere on the board
/パワー段/PWM_AL: U2.38 (INLA); also elsewhere on the board
/パワー段/PWM_BH: U2.39 (INHB); also elsewhere on the board
/パワー段/PWM_BL: U2.40 (INLB); also elsewhere on the board
/パワー段/PWM_CH: U2.41 (INHC); also elsewhere on the board
/パワー段/PWM_CL: U2.42 (INLC); also elsewhere on the board
GND: C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C18.2, C19.2, C20.2, C22.2, C23.2, C25.2, C26.2, D3.2 (A), NT2.2, NT4.2, NT6.2, R7.2, R8.2, R10.2, R11.2, R13.2, R15.2, TH1.2, U2.2 (PGND), U2.27 (DGND), U2.29 (MODE), U2.35 (AGND), U2.43 (BGND), U2.49 (PAD); also elsewhere on the board
unnamed: C45.2, NT1.2, Q2.1 (S), Q2.2 (S), Q2.3 (S), R11.1
unnamed: C46.2, NT3.2, Q4.1 (S), Q4.2 (S), Q4.3 (S), R13.1
unnamed: C47.2, NT5.2, Q6.1 (S), Q6.2 (S), Q6.3 (S), R15.1
unnamed: C17.2, D3.1 (K), L1.1, U2.45 (SW)
unnamed: J2.1, Q1.1 (S), Q1.2 (S), Q1.3 (S), Q2.5 (D), TP3.1, U2.9 (SHA)
unnamed: J3.1, Q3.1 (S), Q3.2 (S), Q3.3 (S), Q4.5 (D), TP6.1, U2.16 (SHB)
unnamed: J4.1, Q5.1 (S), Q5.2 (S), Q5.3 (S), Q6.5 (D), TP9.1, U2.19 (SHC)
unnamed: Q1.4 (G), TP1.1, U2.8 (GHA)
unnamed: Q2.4 (G), TP2.1, U2.10 (GLA)
unnamed: Q3.4 (G), TP4.1, U2.17 (GHB)
unnamed: Q4.4 (G), TP5.1, U2.15 (GLB)
unnamed: Q5.4 (G), TP7.1, U2.18 (GHC)
unnamed: Q6.4 (G), TP8.1, U2.20 (GLC)
unnamed: C17.1, U2.44 (CB)
unnamed: C16.1, U2.4 (CPH)
unnamed: C16.2, U2.3 (CPL)
unnamed: C10.1, TP14.1, U2.32 (GAIN), U2.36 (DVDD)
unnamed: R9.2, R10.1, U2.1 (FB)
unnamed: R7.1, U2.30 (IDRIVE)
unnamed: NT2.1, U2.12 (SNA)
unnamed: NT4.1, U2.13 (SNB)
unnamed: NT6.1, U2.22 (SNC)
unnamed: R4.1, TP10.1, U2.25 (SOA)
unnamed: R5.1, TP11.1, U2.24 (SOB)
unnamed: R6.1, TP12.1, U2.23 (SOC)
unnamed: NT1.1, U2.11 (SPA)
unnamed: NT3.1, U2.14 (SPB)
unnamed: NT5.1, U2.21 (SPC)
unnamed: C15.1, TP13.1, U2.5 (VCP)
unnamed: NT7.1, U2.7 (VDRAIN)
unnamed: R8.1, U2.31 (VDS)
VBUS: C12.1, C13.1, C14.1, C15.2, C19.1, C20.1, C22.1, C23.1, C25.1, C26.1, C45.1, C46.1, C47.1, NT7.2, Q1.5 (D), Q3.5 (D), Q5.5 (D), U2.6 (VM), U2.47 (VIN); also elsewhere on the board

Notes on the sheet:
ゲートドライバ・5V降圧 (DRV8323RH)
A相 ハーフブリッジ
B相 ハーフブリッジ
C相 ハーフブリッジ
FET温度検出 (NTCはFET近傍に配置)

Board: 4 copper layers, 92.0 x 68.0 mm, 145 parts (0 on the bottom side), 92 nets.

Other parts of the board:
H1, H2, H3, H4: M3; M3_Mount_moteus

File kicad/production/pancake_bom_jlc.csv:

Comment,Designator,Footprint,LCSC Part #
100uF 63V,"C1,C2,C3",CP_Elec_10x10.5,C46528099
1uF 50V,"C4,C5,C10,C15,C33,C40,C43,C49,C50",C_0603_1608Metric,C15849
1nF,"C6,C7,C8,C9",C_0402_1005Metric,C1523
100nF,"C11,C17,C28,C29,C30,C32,C34,C37,C39,C42,C48",C_0402_1005Metric,C307331
100nF 100V,"C12,C19,C22,C25",C_0805_2012Metric,C28233
10uF 50V,C13,C_1206_3216Metric,C13585
2.2uF 100V,"C14,C20,C23,C26",C_1210_3225Metric,C55151
47nF 50V,C16,C_0603_1608Metric,C1622
22uF 25V,C18,C_1206_3216Metric,C12891
4.7uF 16V,C31,C_0603_1608Metric,C19666
15pF,"C35,C36",C_0402_1005Metric,C1548
10uF 25V,"C38,C41",C_0805_2012Metric,C15850
4.7nF,C44,C_0402_1005Metric,C1538
1uF 50V,"C45,C46,C47",C_1206_3216Metric,C1848
SMBJ30A,D1,D_SMB,C113998
BAT54C,D2,SOT-23,C37704
SS16,D3,D_SMA,C2481
LED,"D4,D5",LED_0603_1608Metric,C2286
ESDCAN24-2BLY,D6,SOT-23,C246766
22uH,L1,L_Sunlord_SWPA6045S,C83454
NTMFS5C628NLT1G,"Q1,Q2,Q3,Q4,Q5,Q6",ONSemi_SO-8FL_488AA,C145537
100k,"R1,R9",R_0402_1005Metric,C25741
5.6k,R2,R_0402_1005Metric,C25908
10k,"R3,R17,R18",R_0402_1005Metric,C25744
100,"R4,R5,R6,R21,R22,R23,R24,R25,R26",R_0402_1005Metric,C25076
18k,"R7,R8,R10",R_0402_1005Metric,C25762
0.5m,"R11,R13,R15",R_2512_6332Metric,C710260
1k,"R19,R20",R_0402_1005Metric,C11702
120,"R27,R28,R29,R30",R_0402_1005Metric,C25079
RESET,SW1,SW_Push_1P1T_XKB_TS-1187A,C318884
10k NTC,TH1,R_0603_1608Metric,C13564
RT9013-33GB,U1,SOT-23-5,C47773
DRV8323RHRGZR,U2,Texas_RGZ0048A_VQFN-48-1EP_7x7mm_P0.5mm_EP5.15x5.15mm_ThermalVias,C543035
STM32G474CBT6,U3,LQFP-48_7x7mm_P0.5mm,C730123
SRV05-4,"U4,U5",SOT-23-6,C85364
CA-IS2062A,U6,CA-IS2062A_LGA-16_4.65x5.2mm_P0.65mm,C22438481
SN74LVC1G17,"U7,U8,U9",SOT-23-5,C2862344
8MHz,Y1,Crystal_SMD_3225-4Pin_3.2x2.5mm,C5308003
